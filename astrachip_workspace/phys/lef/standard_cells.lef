VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
LAYER M1
  TYPE ROUTING ;
  DIRECTION HORIZONTAL ;
END M1
MACRO ALU
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 10 BY 10 ;
END ALU
END LIBRARY
